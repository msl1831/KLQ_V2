LR_IROM1 0x08000000 0x00001800 {
  ER_IROM1 0x08000000 0x00001800 {
    *.o (RESET, +First)
    *(+RO)
  }
  RW_IRAM1 0x20000000 0x00000C00 {
    *(+RW +ZI)
  }
}
