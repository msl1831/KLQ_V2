LR_IROM1 0x08001800 0x00004780 {
  ER_IROM1 0x08001800 0x00004780 {
    *.o (RESET, +First)
    *(+RO)
  }
  RW_IRAM1 0x20000000 0x00000C00 {
    *(+RW +ZI)
  }
}
