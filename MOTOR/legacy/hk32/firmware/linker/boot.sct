LR_IROM1 0x08000000 0x00001200 {
  ER_IROM1 0x08000000 0x00001200 {
    *.o (RESET, +First)
    *(+RO)
  }
  RW_IRAM1 0x20000000 0x00000800 {
    *(+RW +ZI)
  }
}
