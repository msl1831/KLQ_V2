LR_IROM1 0x08001200 0x00002D80 {
  ER_IROM1 0x08001200 0x00002D80 {
    *.o (RESET, +First)
    *(+RO)
  }
  RW_IRAM1 0x20000000 0x00000800 {
    *(+RW +ZI)
  }
}
